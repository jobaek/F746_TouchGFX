<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\F746DISCO_TouchGFX_Start.ewp</path>
  </project>
  <batchBuild />
</workspace>
